# Keil uVision project lora.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: LPC4088FBD144 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lora +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: lora.c
    D:/arm keil/Local/Arm/Startup/NXP/LPC407x_8x_177x_8x/: system_LPC407x_8x_177x_8x.c
